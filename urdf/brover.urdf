Commit message: brover lidar pose

File: urdf/brover.urdf (robot description, URDF)
Before this commit: robot turtlebro, 6 links, 5 joints
Joints:
- joint scan_joint: origin xyz=0.0 0 0.08 rpy=0 0 3.1415 -> xyz=0.1 -0.065 0.08 rpy=0 0 3.1415
